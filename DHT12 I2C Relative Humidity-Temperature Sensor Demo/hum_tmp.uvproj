# Keil uVision project hum_tmp.uvproj, settings and files
target Hum_Temp (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: hum_tmp +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include;.\My_Libraries\Software Delay;.\My_Libraries\I2C;.\My_Libraries\DHT12;.\My_Libraries\3 Wire LCD
  group Source
    ./: main.c
  group Common
    ./Common/: Common.c Delay.c
  group My_Libraries
    ./My_Libraries/3 Wire LCD/: LCD_3_Wire.c lcd_print.c
    ./My_Libraries/Software Delay/: soft_delay.c
    ./My_Libraries/I2C/: I2C.c
    ./My_Libraries/DHT12/: DHT12.c
  group Startup
    ./Startup/: STARTUP.A51
