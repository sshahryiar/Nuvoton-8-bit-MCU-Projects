# Keil uVision project thermo.uvproj, settings and files
target Thermo (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: thermo +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include;.\My_Libraries\Software Delay;.\My_Libraries\2 Wire LCD;.\Common;.\My_Libraries\MAX31855;.\My_Libraries\LCD Print
  group Source
    ./: main.c
  group Common
    ./Common/: Common.c Delay.c
  group My_Libraries
    ./My_Libraries/Software Delay/: soft_delay.c
    ./My_Libraries/2 Wire LCD/: LCD_2_Wire.c PCF8574.c SW_I2C.c
    ./My_Libraries/MAX31855/: MAX31855.c
    ./My_Libraries/LCD Print/: lcd_print.c
  group Startup
    ./Startup/: STARTUP.A51
