# Keil uVision project solar_irradiation_meter.uvproj, settings and files
target solar_irradiation_meter (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: solar_irradiation_meter +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\Include;..\My_Libraries\2 Wire LCD  (Software Delay);..\My_Libraries\Software Delay;..\My_Libraries\Extended Functions
  group Source
    ./: main.c
  group Common
    ../Common/: Common.c Delay.c
  group My_Libraries
    ../My_Libraries/2 Wire LCD  (Software Delay)/: LCD_2_Wire.c PCF8574.c SW_I2C.c
    ../My_Libraries/Software Delay/: soft_delay.c
  group Startup
    ../Startup/: STARTUP.A51
